# Keil uVision project GPIO_driver.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_driver
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: main.c
  group MCAL_SRC
    ./: GPIO.c
    ../../../M.A_Diploma/Drivers/RCC_FILES/: RCC.c
  group MCAL_INC
    ./: GPIO.h GPIO_Private.h GPIO_Cfg.h
    ../../../M.A_Diploma/STM32F42XXX_Device_Drivers/LIB/: STD_TYPES.h
    ../../../M.A_Diploma/Drivers/RCC_FILES/: RCC.h RCC_CONFIG.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
